# Keil uVision project TW8836B2_EVB11.uvproj, settings and files
target Target 1 (MCS-51)
  device: DP80390XP Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2 MOD517AU
  output: TW8836B_EVB11 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: EVB_11 nullFn="//"
  c include: .\source\app;.\source\common;.\source\drv;.\source\HW;.\source\utils;.\source\test
  link misc: RECURSIONS (30)
  group common
    ./source/common/: L51_BANK.A51
    ./source/app/: main.c interrupt.c
  group HW
    ./source/app/: init.c
    ./source/HW/: HWsysclk.c HWtime.c HWpanel.c
  group utils
    ./source/utils/: Printf.c hmshell.c
  group test
    ./source/test/: change_const_text.c
